# Keil uVision project ALPS.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051 Core CAST, Inc.
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ALPS
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ../CORE/: STARTUP.A51
    ./: ALPS.c
